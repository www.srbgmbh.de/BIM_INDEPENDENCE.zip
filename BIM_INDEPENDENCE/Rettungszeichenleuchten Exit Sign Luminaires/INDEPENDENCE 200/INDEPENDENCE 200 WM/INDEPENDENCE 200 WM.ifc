Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-08-30T11:02:07+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: INDEPENDENCE 200 WM:INDEPENDENCE 200 WM - 260 lm - Zentralbatterie, INDEPENDENCE 200 WM:INDEPENDENCE 200 WM - 260 lm - Zentralbatterie:2487288
In: Default
Type - Material: Stainless steel V4A, Kunststoff - PMMA, Kunststoff -PVC, Vorgabe
Type - Pset_ElementShading - Color: white
Material: Vorgabe
Pset_DistributionFlowElementCommon - Reference: INDEPENDENCE 200 WM - 260 lm - Zentralbatterie; sets with these values: 2
